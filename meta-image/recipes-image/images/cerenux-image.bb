SUMMARY = "A very basic custom image with a terminal"

LICENCE = "MIT"

inherit core-image





